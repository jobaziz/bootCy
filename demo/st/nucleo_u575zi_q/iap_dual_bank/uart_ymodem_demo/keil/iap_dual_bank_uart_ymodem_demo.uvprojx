# Keil uVision project iap_dual_bank_uart_ymodem_demo.uvprojx, settings and files
target iap_dual_bank_uart_ymodem_demo (6160000::V6.16::ARMCLANG)
  device: STM32U575ZITxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: iap_dual_bank_uart_ymodem_demo
  BeforeMake: ..\..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: python.exe ..\scripts\misc\copy_file.py .\iap_dual_bank_uart_ymodem_demo.bin ..\
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32U575xx USE_HAL_DRIVER USE_STM32U5XX_NUCLEO FLASH_DB_MODE __USE_C99_MATH
  c include: ..\src;..\..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\..\third_party\st\devices\stm32u5xx;..\..\..\..\..\..\third_party\st\drivers\stm32u5xx_hal_driver\inc;..\..\..\..\..\..\third_party\st\boards\stm32u5xx_nucleo;..\..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\..\third_party\freertos\portable\gcc\arm_cm33_ntz\non_secure;..\..\..\..\..\..\common;..\..\..\..\..\..\cyclone_crypto;..\..\..\..\..\..\cyclone_boot
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\stm32u575_flash.sct
  group Demo Sources
    ./: startup_stm32u575xx.s retarget.c
    ../src/: system_stm32u5xx.c stm32u5xx_it.c stm32u5xx_hal_timebase_tim.c main.c debug.c res.c uart_user.c common.c ymodem.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h stm32u5xx_hal_conf.h stm32u5xx_nucleo_conf.h stm32u5xx_it.h uart_user.h boot_config.h crypto_config.h uart_user.h common.h ymodem.h version.h
  group Common Sources
    ../../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneBOOT Sources
    ../../../../../../cyclone_boot/core/: crc32.c
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32u5xx_mcu_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32u5xx_flash_driver.c
    ../../../../../../cyclone_boot/image/: image.c image_process.c image_utils.c
    ../../../../../../cyclone_boot/memory/: memory.c memory_ex.c
    ../../../../../../cyclone_boot/security/: verify.c verify_auth.c verify_sign.c cipher.c
    ../../../../../../cyclone_boot/update/: update.c update_misc.c update_fallback.c
  group CycloneBOOT Headers
    ../../../../../../cyclone_boot/core/: cboot_error.h crc32.h flash.h mcu.h
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32u5xx_mcu_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32u5xx_flash_driver.h
    ../../../../../../cyclone_boot/image/: image.h image_process.h image_utils.h
    ../../../../../../cyclone_boot/memory/: memory.h memory_ex.h
    ../../../../../../cyclone_boot/security/: verify.h verify_auth.h verify_sign.h cipher.h
    ../../../../../../cyclone_boot/update/: update.h update_misc.h update_fallback.h
  group CycloneCRYPTO Sources
    ../../../../../../cyclone_crypto/hardware/stm32u5xx/: stm32u5xx_crypto.c stm32u5xx_crypto_trng.c
    ../../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.c
    ../../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c
    ../../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../../cyclone_crypto/pkix/: pem_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_cert_parse.c x509_cert_validate.c x509_cert_ext_parse.c x509_common.c x509_sign_parse.c x509_sign_verify.c
    ../../../../../../cyclone_crypto/kdf/: hkdf.c
    ../../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../../cyclone_crypto/hardware/stm32u5xx/: stm32u5xx_crypto.h stm32u5xx_crypto_trng.h
    ../../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.h
    ../../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h
    ../../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../../cyclone_crypto/pkix/: pem_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_cert_parse.h x509_cert_validate.h x509_cert_ext_parse.h x509_common.h x509_sign_parse.h x509_sign_verify.h
    ../../../../../../cyclone_crypto/kdf/: hkdf.h
    ../../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: port.c portasm.c
    ../../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: portmacro.h portasm.h
    ../../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group Nucleo-U575ZI-Q Sources
    ../../../../../../third_party/st/boards/stm32u5xx_nucleo/: stm32u5xx_nucleo.c stm32u5xx_nucleo_usbpd_pwr.c
  group Nucleo-U575ZI-Q Headers
    ../../../../../../third_party/st/boards/stm32u5xx_nucleo/: stm32u5xx_nucleo.h stm32u5xx_nucleo_usbpd_pwr.h stm32u5xx_nucleo_errno.h
  group STM32U5xx HAL Drivers Sources
    ../../../../../../third_party/st/drivers/stm32u5xx_hal_driver/src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_fmac.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_irda.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_nand.c stm32u5xx_hal_nor.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_otfdec.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_smartcard.c stm32u5xx_hal_smartcard_ex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_smbus_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c stm32u5xx_ll_adc.c stm32u5xx_ll_comp.c stm32u5xx_ll_cordic.c stm32u5xx_ll_crc.c stm32u5xx_ll_crs.c stm32u5xx_ll_dac.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_dma.c stm32u5xx_ll_dma2d.c stm32u5xx_ll_exti.c stm32u5xx_ll_fmac.c stm32u5xx_ll_fmc.c stm32u5xx_ll_gpio.c stm32u5xx_ll_i2c.c stm32u5xx_ll_icache.c stm32u5xx_ll_lpgpio.c stm32u5xx_ll_lptim.c stm32u5xx_ll_lpuart.c stm32u5xx_ll_opamp.c stm32u5xx_ll_pka.c stm32u5xx_ll_pwr.c stm32u5xx_ll_rcc.c stm32u5xx_ll_rng.c stm32u5xx_ll_rtc.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_spi.c stm32u5xx_ll_tim.c stm32u5xx_ll_ucpd.c stm32u5xx_ll_usart.c stm32u5xx_ll_usb.c stm32u5xx_ll_utils.c
  group STM32U5xx HAL Drivers Headers
    ../../../../../../third_party/st/drivers/stm32u5xx_hal_driver/inc/: stm32u5xx_hal.h stm32u5xx_hal_adc.h stm32u5xx_hal_adc_ex.h stm32u5xx_hal_comp.h stm32u5xx_hal_cordic.h stm32u5xx_hal_cortex.h stm32u5xx_hal_crc.h stm32u5xx_hal_crc_ex.h stm32u5xx_hal_cryp.h stm32u5xx_hal_cryp_ex.h stm32u5xx_hal_dac.h stm32u5xx_hal_dac_ex.h stm32u5xx_hal_dcache.h stm32u5xx_hal_dcmi.h stm32u5xx_hal_def.h stm32u5xx_hal_dma.h stm32u5xx_hal_dma2d.h stm32u5xx_hal_dma_ex.h stm32u5xx_hal_exti.h stm32u5xx_hal_fdcan.h stm32u5xx_hal_flash.h stm32u5xx_hal_flash_ex.h stm32u5xx_hal_fmac.h stm32u5xx_hal_gpio.h stm32u5xx_hal_gpio_ex.h stm32u5xx_hal_gtzc.h stm32u5xx_hal_hash.h stm32u5xx_hal_hash_ex.h stm32u5xx_hal_hcd.h stm32u5xx_hal_i2c.h stm32u5xx_hal_i2c_ex.h stm32u5xx_hal_icache.h stm32u5xx_hal_irda.h stm32u5xx_hal_irda_ex.h stm32u5xx_hal_iwdg.h stm32u5xx_hal_lptim.h stm32u5xx_hal_mdf.h stm32u5xx_hal_mmc.h stm32u5xx_hal_mmc_ex.h stm32u5xx_hal_nand.h stm32u5xx_hal_nor.h stm32u5xx_hal_opamp.h stm32u5xx_hal_opamp_ex.h stm32u5xx_hal_ospi.h stm32u5xx_hal_otfdec.h stm32u5xx_hal_pcd.h stm32u5xx_hal_pcd_ex.h stm32u5xx_hal_pka.h stm32u5xx_hal_pssi.h stm32u5xx_hal_pwr.h stm32u5xx_hal_pwr_ex.h stm32u5xx_hal_ramcfg.h stm32u5xx_hal_rcc.h stm32u5xx_hal_rcc_ex.h stm32u5xx_hal_rng.h stm32u5xx_hal_rng_ex.h stm32u5xx_hal_rtc.h stm32u5xx_hal_rtc_ex.h stm32u5xx_hal_sai.h stm32u5xx_hal_sai_ex.h stm32u5xx_hal_sd.h stm32u5xx_hal_sd_ex.h stm32u5xx_hal_smartcard.h stm32u5xx_hal_smartcard_ex.h stm32u5xx_hal_smbus.h stm32u5xx_hal_smbus_ex.h stm32u5xx_hal_spi.h stm32u5xx_hal_spi_ex.h stm32u5xx_hal_sram.h stm32u5xx_hal_tim.h stm32u5xx_hal_tim_ex.h stm32u5xx_hal_tsc.h stm32u5xx_hal_uart.h stm32u5xx_hal_uart_ex.h stm32u5xx_hal_usart.h stm32u5xx_hal_usart_ex.h stm32u5xx_hal_wwdg.h stm32u5xx_ll_adc.h stm32u5xx_ll_bus.h stm32u5xx_ll_comp.h stm32u5xx_ll_cordic.h stm32u5xx_ll_cortex.h stm32u5xx_ll_crc.h stm32u5xx_ll_crs.h stm32u5xx_ll_dac.h stm32u5xx_ll_dcache.h stm32u5xx_ll_dlyb.h stm32u5xx_ll_dma.h stm32u5xx_ll_dma2d.h stm32u5xx_ll_exti.h stm32u5xx_ll_fmac.h stm32u5xx_ll_fmc.h stm32u5xx_ll_gpio.h stm32u5xx_ll_i2c.h stm32u5xx_ll_icache.h stm32u5xx_ll_iwdg.h stm32u5xx_ll_lpgpio.h stm32u5xx_ll_lptim.h stm32u5xx_ll_lpuart.h stm32u5xx_ll_opamp.h stm32u5xx_ll_pka.h stm32u5xx_ll_pwr.h stm32u5xx_ll_rcc.h stm32u5xx_ll_rng.h stm32u5xx_ll_rtc.h stm32u5xx_ll_sdmmc.h stm32u5xx_ll_spi.h stm32u5xx_ll_system.h stm32u5xx_ll_tim.h stm32u5xx_ll_ucpd.h stm32u5xx_ll_usart.h stm32u5xx_ll_usb.h stm32u5xx_ll_utils.h stm32u5xx_ll_wwdg.h
