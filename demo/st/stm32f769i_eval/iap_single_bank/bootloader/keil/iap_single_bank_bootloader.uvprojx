# Keil uVision project iap_single_bank_bootloader.uvprojx, settings and files
target iap_single_bank_bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: iap_single_bank_bootloader
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: python.exe ..\scripts\misc\copy_file.py .\iap_single_bank_bootloader.bin ..\
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F769xx USE_HAL_DRIVER USE_STM32F769I_EVAL USE_IOEXPANDER
  c include: ..\src;..\..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\..\third_party\st\devices\stm32f7xx;..\..\..\..\..\..\third_party\st\drivers\stm32f7xx_hal_driver\inc;..\..\..\..\..\..\third_party\st\boards\stm32f769i_eval;..\..\..\..\..\..\common;..\..\..\..\..\..\cyclone_tcp;..\..\..\..\..\..\cyclone_crypto;..\..\..\..\..\..\cyclone_boot
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\stm32f769_flash.sct
  group Demo Sources
    ./: startup_stm32f769xx.s retarget.c
    ../src/: system_stm32f7xx.c stm32f7xx_it.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h boot_config.h stm32f7xx_hal_conf.h stm32f7xx_it.h crypto_config.h
  group Common Sources
    ../../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c path.c
  group Common Headers
    ../../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h error.h debug.h
  group CycloneBOOT Sources
    ../../../../../../cyclone_boot/core/: crc32.c
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32f7xx_mcu_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32f7xx_flash_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/external/: n25q512a_flash_driver.c
    ../../../../../../cyclone_boot/image/: image.c
    ../../../../../../cyclone_boot/memory/: memory.c
    ../../../../../../cyclone_boot/security/: cipher.c
    ../../../../../../cyclone_boot/bootloader/: boot.c boot_fallback.c boot_common.c
  group CycloneBOOT Headers
    ../../../../../../cyclone_boot/core/: cboot_error.h crc32.h flash.h mcu.h
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32f7xx_mcu_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32f7xx_flash_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/external/: n25q512a_flash_driver.h
    ../../../../../../cyclone_boot/image/: image.h
    ../../../../../../cyclone_boot/memory/: memory.h memory_ex.h
    ../../../../../../cyclone_boot/security/: cipher.h
    ../../../../../../cyclone_boot/bootloader/: boot.h boot_fallback.h boot_common.h
  group CycloneCRYPTO Sources
    ../../../../../../cyclone_crypto/hash/: sha256.c
    ../../../../../../cyclone_crypto/cipher/: aes.c
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.c
  group CycloneCRYPTO Headers
    ../../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../../cyclone_crypto/cipher/: aes.h
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.h
  group STM32F769I-EVAL Sources
    ../../../../../../third_party/st/boards/stm32f769i_eval/: stm32f769i_eval.c stm32f769i_eval_camera.c stm32f769i_eval_eeprom.c stm32f769i_eval_io.c stm32f769i_eval_lcd.c stm32f769i_eval_nor.c stm32f769i_eval_qspi.c stm32f769i_eval_sd.c stm32f769i_eval_sdram.c stm32f769i_eval_sram.c stm32f769i_eval_ts.c
    ../../../../../../third_party/st/boards/components/ft6x06/: ft6x06.c
    ../../../../../../third_party/st/boards/components/s5k5cag/: s5k5cag.c
    ../../../../../../third_party/st/boards/components/otm8009a/: otm8009a.c
    ../../../../../../third_party/st/boards/components/ov5640/: ov5640.c
    ../../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.c
  group STM32F769I-EVAL Headers
    ../../../../../../third_party/st/boards/stm32f769i_eval/: stm32f769i_eval.h stm32f769i_eval_camera.h stm32f769i_eval_eeprom.h stm32f769i_eval_io.h stm32f769i_eval_lcd.h stm32f769i_eval_nor.h stm32f769i_eval_qspi.h stm32f769i_eval_sd.h stm32f769i_eval_sdram.h stm32f769i_eval_sram.h stm32f769i_eval_ts.h
    ../../../../../../third_party/st/boards/components/n25q512a/: n25q512a.h
    ../../../../../../third_party/st/boards/components/ft6x06/: ft6x06.h
    ../../../../../../third_party/st/boards/components/s5k5cag/: s5k5cag.h
    ../../../../../../third_party/st/boards/components/otm8009a/: otm8009a.h
    ../../../../../../third_party/st/boards/components/ov5640/: ov5640.h
    ../../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.h
  group STM32F7xx HAL Drivers Sources
    ../../../../../../third_party/st/drivers/stm32f7xx_hal_driver/src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group STM32F7xx HAL Drivers Headers
    ../../../../../../third_party/st/drivers/stm32f7xx_hal_driver/inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.h
